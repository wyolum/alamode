# Repository wyolum/alamode

File README.md:

alamode
=======

Code, test code, and examples for the Alamode Arduino Compatible add on for Raspberry Pi.

License
-------
[CERN Open Hardware Licence v1.2 ]

[CERN Open Hardware Licence v1.2 ]:http://www.ohwr.org/attachments/2388/cern_ohl_v_1_2.txt

## KiCad design kicad/aLaMode_v3.kicad_pcb

Board: 2 copper layers, 85.1 x 55.9 mm, 79 parts (22 on the bottom side), 59 nets.

Parts:
B2, B3, B15: I/O; I_O
BT1: BATT_RTC; CR1632_2
C1, C2, C4, C7, C9, C12, C13, C14: 100n; c_0805
C3: 2u2 Tant; c_0805
C5: 2u2; c_0805
C6: 100u,25V; C_ELCO_SMD
C8: 47u,10V; C_ELCO_SMD
C10, C11: 22p; c_0805
C15: 1n; c_0805
C16: 10n; c_0805
D1: 5V0; led_0805
D2: 3V3; led_0805
D3, D4: RB886G; d_VMD2
D5, D8: MBRM110LT1G; do_457
D7: SMBJ5.0CA-TR; diode-DO214AA
D13: BLINK; led_0805
DIP1: DIP
F1, F2: nanoSMDC110F; f_1206
G1, G2: Logo_Wyolum; Logo-WL3
G3, G4: Logo_OH; OSHW_6mm
IC1: ATMEGA328-PU; DIP-28__300_ELL
P1: BCM2835_GPIO; Header_GPIO
P2: GPU_JTAG; Header_GPU_JTAG
P3: LAN_JTAG; Header_GPU_JTAG
P4: PWM_SERVO; Header_Servo
P5: 5V_SERVO; Header_Servo
P6: GND_SERVO; Header_Servo
P7: GPS_UP501; Header_GPS
P8: FTDI; Header_FTDI
P9: ICSP; Header_ICSP
P10: V_IN; JACK_ALIM
P11: U6_OE; Header_U6OE_SMT
P12: UUSB_B; USB_B_Micro
P13: AREF; Header_A_REF
P14: ANALOG_5V0; Header_6x1
P15: ANALOG_GND; Header_6x1
P16: 5V_LINK; Header_U6OE_SMT
Q1: FDN340P; SOT23-3
R1, R2, R3, R4, R6, R7, R9, R10, R11, R13: 10k; r_0805
R5, R8: 1k5; r_0805
R12: 1k; r_0805
R14: 0E; r_0805
R15: 8k2; r_0805
R16: 16k; r_0805
SD1: SD_CARD_MICRO; SD_Micro
SHIELD1: ARDUINO_SHIELD; ARDUINO_SHIELD_2_040pins
SW1: RST; SW_SMD
U1: LP2985-33DBVR; SOT23-5
U2: 74HC125; SO14E
U3: NCP1117ST50T3G; SOT223
U4: DS3231N; DS3231
U5: LM358N; SO8E
U6: TXS0108; tssop-20
X1: 16MHz; Xtal_SMD2

Connections:
/5V_INT: F2.2, P4.7, P4.8
/5V_SERVO: C8.1, D8.2, P5.1, P5.2, P5.3, P5.4, P5.5, P5.6, P5.7, P5.8
/AREF: IC1.21, P13.2, SHIELD1.AREF
/GPS_BAT: D3.2, D4.2, P7.5
/GPS_Rx: P7.1, R15.2, R16.1
/PB0: IC1.14, SHIELD1.8
/PB1: IC1.15, P4.4, SHIELD1.9
/PB6: C10.1, IC1.9, X1.1
/PB7: C11.1, IC1.10, X1.2
/PC0: IC1.23, SHIELD1.AD0
/PC1: IC1.24, SHIELD1.AD1
/PC2: IC1.25, SHIELD1.AD2
/PC3: IC1.26, SHIELD1.AD3
/PD2_1pps: IC1.4, P7.6, SHIELD1.2
/PD4_GPS_Rx: IC1.6, R15.1, SHIELD1.4
/PD5: IC1.11, P4.2, SHIELD1.5
/PD6_GPS_Tx: IC1.12, P4.3, P7.2, SHIELD1.6
/PD7: IC1.13, SHIELD1.7
/RPi/5V0: C1.1, C2.1, C3.1, C4.1, C12.2, C15.1, D7.1, F1.2, F2.1, IC1.7, IC1.20, P9.2, P13.3, P14.1, P14.2, P14.3, P16.1, Q1.S, R1.1, R2.1, R5.1, R7.1, R9.1, R14.2, SHIELD1.5V, U1.1, U1.3, U3.2, U3.4, U4.2, U5.8, U6.19
/RPi/MISO: IC1.18, P9.1, SD1.7, SHIELD1.12, U6.13
/RPi/MOSI: IC1.17, P4.6, P9.4, R4.2, SHIELD1.11, U2.5, U6.14
/RPi/RESET: C7.2, IC1.1, P9.5, R7.2, SHIELD1.RST, SW1.2, U6.15
/RPi/RXD: IC1.2, P8.4, SHIELD1.0, U6.17
/RPi/Rpi_3V3: C13.2, P1.1, P11.1, P11.2, R13.1, U6.2, U6.10
/RPi/Rpi_5V0: P1.2, P16.2
/RPi/Rpi_MISO: P1.21, U6.8
/RPi/Rpi_MOSI: P1.19, U6.7
/RPi/Rpi_RST: P1.12, U6.6
/RPi/Rpi_Rx: P1.10, U6.5
/RPi/Rpi_SCK: P1.23, U6.9
/RPi/Rpi_SCL: P1.5, U6.3
/RPi/Rpi_SDA: P1.3, U6.1
/RPi/Rpi_Tx: P1.8, U6.4
/RPi/SCK: IC1.19, P9.3, R6.2, SHIELD1.13, U2.2, U5.5, U6.12
/RPi/SCL: IC1.28, R1.2, SHIELD1.AD5, U4.16, U6.18
/RPi/SDA: IC1.27, R2.2, SHIELD1.AD4, U4.15, U6.20
/RPi/TXD: IC1.3, P8.5, SHIELD1.1, U6.16
/SD_CLK: SD1.5, U2.3
/SD_CS: SD1.2, U2.8
/SD_DATA_IN: SD1.3, U2.6
/SS: IC1.16, P4.5, R3.2, SHIELD1.10, U2.9
/aLaMode_pwr/CMP: R10.2, R11.1, U5.3
/aLaMode_pwr/GATE_CMD: Q1.G, U5.1
/aLaMode_pwr/PWR_IN: D5.1, P10.1
/aLaMode_pwr/USBVCC: P8.3, Q1.D
/aLaMode_pwr/USB_IN: F1.1, P12.1
/aLaMode_pwr/V_IN: C6.1, D5.2, R10.1, R14.1, SHIELD1.V_IN, U3.3
/aLaMode_rtc/32k: B15.1, U4.1
/aLaMode_rtc/BAT: BT1.+, C9.1, D4.1, U4.14
/aLaMode_rtc/PD3_SQW: B2.1, IC1.5, P4.1, R9.2, SHIELD1.3, U4.3
/aLaMode_rtc/RST: B3.1, U4.4
/~RTS: C7.1, P8.6
GND: BT1.-, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.1, C15.2, C16.2, D1.2, D2.2, D7.2, D8.1, D13.2, IC1.8, IC1.22, P1.6, P6.1, P6.2, P6.3, P6.4, P6.5, P6.6, P6.7, P6.8, P7.3, P8.1, P8.2, P9.6, P10.2, P10.3, P11.3, P12.5, P12.T1, P12.T2, P12.T3, P12.T4, P12.T5, P12.T6, P15.1, P15.2, P15.3, P15.4, P15.5, P15.6, R11.2, R13.2, R16.2, SD1.6, SD1.G1, SD1.G2, SD1.G3, SD1.G4, SHIELD1.GND1, SHIELD1.GND2, SHIELD1.GND3, SW1.1, U1.2, U2.1, U2.4, U2.7, U2.10, U3.1, U4.5, U4.6, U4.7, U4.8, U4.9, U4.10, U4.11, U4.12, U4.13, U5.4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
unnamed: C16.1, U1.4
unnamed: D1.1, R5.2
unnamed: D2.1, R8.2
unnamed: D13.1, R12.2
unnamed: R12.1, U5.6, U5.7
VCC: C5.1, C14.2, D3.1, P7.4, P13.1, P14.4, P14.5, P14.6, R3.1, R4.1, R6.1, R8.1, SD1.4, SHIELD1.3V3, U1.5, U2.12, U2.13, U2.14, U5.2

File kicad/aLaMode_v3_BoM_sch.csv:

Reference, Value, Footprint, Datasheet
P14,ANALOG_5V0,alamode_fp:Header_6x1,
P15,ANALOG_GND,alamode_fp:Header_6x1,
P13,AREF,alamode_fp:Header_A_REF,
P9,ICSP,alamode_fp:Header_ICSP,
C7,100n,alamode_fp:c_0805,
P8,FTDI,alamode_fp:Header_FTDI,
F2,nanoSMDC110F,alamode_fp:f_1206,
D8,MBRM110LT1G,alamode_fp:do_457,
C14,100n,alamode_fp:c_0805,
C8,47u,10V,alamode_fp:C_ELCO_SMD,
P6,GND_SERVO,alamode_fp:Header_Servo,
P5,5V_SERVO,alamode_fp:Header_Servo,
P4,PWM_SERVO,alamode_fp:Header_Servo,
DIP1,DIP,alamode_fp:DIP,
SHIELD1,ARDUINO_SHIELD,alamode_fp:ARDUINO_SHIELD_2_040pins,
IC1,ATMEGA328-PU,alamode_fp:DIP-28__300_ELL,
D4,RB886G,alamode_fp:d_VMD2,
D3,RB886G,alamode_fp:d_VMD2,
P7,GPS_UP501,alamode_fp:Header_GPS,
X1,16MHz,alamode_fp:Xtal_SMD2,
C11,22p,alamode_fp:c_0805,
C10,22p,alamode_fp:c_0805,
SD1,SD_CARD_MICRO,alamode_fp:SD_Micro,
U2,74HC125,alamode_fp:SO14E,
R2,10k,alamode_fp:r_0805,
R1,10k,alamode_fp:r_0805,
SW1,RST,alamode_fp:SW_SMD,
R7,10k,alamode_fp:r_0805,
C1,100n,alamode_fp:c_0805,
R3,10k,alamode_fp:r_0805,
R4,10k,alamode_fp:r_0805,
R6,10k,alamode_fp:r_0805,
R15,8k2,alamode_fp:r_0805,
R16,16k,alamode_fp:r_0805,
R14,0E,alamode_fp:r_0805,
R5,1k5,alamode_fp:r_0805,
R8,1k5,alamode_fp:r_0805,
D2,3V3,alamode_fp:led_0805,
D1,5V0,alamode_fp:led_0805,
F1,nanoSMDC110F,alamode_fp:f_1206,
C16,10n,alamode_fp:c_0805,
C15,1n,alamode_fp:c_0805,
D7,SMBJ5.0CA-TR,alamode_fp:diode-DO214AA,
P12,UUSB_B,alamode_fp:USB_B_Micro,
D13,BLINK,alamode_fp:led_0805,
R12,1k,alamode_fp:r_0805,
U5,LM358N,alamode_fp:SO8E,
C2,100n,alamode_fp:c_0805,
U1,LP2985-33DBVR,alamode_fp:SOT23-5,
Q1,FDN340P,alamode_fp:SOT23-3,
R11,10k,alamode_fp:r_0805,
R10,10k,alamode_fp:r_0805,
U3,NCP1117ST50T3G,alamode_fp:SOT223,
D5,MBRM110LT1G,alamode_fp:do_457,
C6,100u,25V,alamode_fp:C_ELCO_SMD,
C3,2u2 Tant,alamode_fp:c_0805,
C5,2u2,alamode_fp:c_0805,
C4,100n,alamode_fp:c_0805,
P10,V_IN,alamode_fp:JACK_ALIM,
G4,Logo_OH,alamode_fp:OSHW_6mm,
G3,Logo_OH,alamode_fp:OSHW_6mm,
G2,Logo_Wyolum,alamode_fp:Logo-WL3,
G1,Logo_Wyolum,alamode_fp:Logo-WL3,
R9,10k,alamode_fp:r_0805,
B15,I/O,alamode_fp:I_O,
B3,I/O,alamode_fp:I_O,
B2,I/O,alamode_fp:I_O,
U4,DS3231N,alamode_fp:DS3231,
C9,100n,alamode_fp:c_0805,
BT1,BATT_RTC,alamode_fp:CR1632_2,
P16,5V_LINK,alamode_fp:Header_U6OE_SMT,
P1,BCM2835_GPIO,alamode_fp:Header_GPIO,
R13,10k,alamode_fp:r_0805,
P3,LAN_JTAG,alamode_fp:Header_GPU_JTAG,
P11,U6_OE,alamode_fp:Header_U6OE_SMT,
C13,100n,alamode_fp:c_0805,
C12,100n,alamode_fp:c_0805,
U6,TXS0108,alamode_fp:tssop-20,
P2,GPU_JTAG,alamode_fp:Header_GPU_JTAG,

## Commit log

2012-09-07 Add Arduino test code for UUT and tester
2012-09-07 Add initial version of test plan docs
2012-09-07 Add Uno Bootloader Hex and Fixed TFT libraries
2012-09-07 Update for first release
2012-09-07 final updates for bundle url
2012-09-16 Initial commit, integrated arduino bundle
2012-10-04 add alamode setup bundle and source
2012-10-22 add web controlled train example
2012-10-24 Add CPUstats example (arduino code)
2012-10-27 Initial commit of AlaModeTester and DigitalTester
2012-10-27 fixed baud rate
2012-11-04 changed bootloader baudrate to support shipping alamodes.
2012-11-04 added shipping bundle with new baud rate
2013-06-17 Fixed typo in error msg in readList()
2013-06-17 Fixed typos
2014-02-25 Update setup
    Updating setup to remember the previous root partition when updating cmdline.txt.
2014-02-25 Update setup
2014-03-14 sed the cmdline.txt instead of copying
2014-03-14 update alamode-setup bundle with sed script
2014-03-24 fix incorrect baud rate
2015-02-16 update patched avrdude
2015-07-27 footprint library upgrade, upgraded to .pretty
2015-07-29 added 3D models folder
2015-07-31 added 3D models
2016-01-21 add setup for Jessie
2016-03-01 add jessie-setup to setup bundle
2016-11-20 bag stickers
2017-09-13 add debian stretch setup support
2017-09-13 set stretch-setup executable
2018-10-20 Update boards.txt for newer versions of arduino IDE
    Also, move from replacing the file in place to concatenating the alamode
    configuration. Closes #5.
